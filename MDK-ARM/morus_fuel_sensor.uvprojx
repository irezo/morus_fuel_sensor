# Keil uVision project morus_fuel_sensor.uvprojx, settings and files
target morus_fuel_sensor (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F334K8 STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20002FFF) IRAM2(0x10000000-0x10000FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: morus_fuel_sensor
  BeforeMake: python ..\libuavcan\libuavcan\dsdl_compiler\libuavcan_dsdlc ../libuavcan/dsdl/uavcan ../morus_uavcan_msgs -I../libuavcan/dsdl/uavcan -O ../dsdlc_generated
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F334x8,UAVCAN_STM32_BAREMETAL=1,STM32_TIMCLK1=36000000,STM32_PCLK1=36000000,UAVCAN_STM32_NUM_IFACES=1,UAVCAN_STM32_TIMER_NUMBER=3,NDEBUG,UAVCAN_CPP_VERSION=UAVCAN_CPP03
  c misc: --cpp --gnu
  c include: ../Inc;  ../Drivers/STM32F3xx_HAL_Driver/Inc;  ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32F3xx/Include;  ../Drivers/CMSIS/Include;  ..\dsdlc_generated;  ..\libuavcan\libuavcan\include;  ..\libuavcan\libuavcan_drivers\stm32\driver\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x10000000 size 0x1000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_pwr.c stm32f3xx_hal_rcc.c
  group Application/UserC
    ../Src/: stm32f3xx_hal_msp.c gpio.c stm32f3xx_it.c flash.c calibration.c liquid_level.c read_register.c register_init.c write_register.c
    ./: stdout_user.c
  group Application/MDK-ARM
    ./: startup_stm32f334x8.s
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group libuavcan
    ../libuavcan/libuavcan/src/driver/: uc_can.cpp
    ../libuavcan/libuavcan/src/marshal/: uc_bit_array_copy.cpp uc_bit_stream.cpp uc_float_spec.cpp uc_scalar_codec.cpp
    ../libuavcan/libuavcan/src/node/: uc_generic_publisher.cpp uc_generic_subscriber.cpp uc_global_data_type_registry.cpp uc_scheduler.cpp uc_service_client.cpp uc_timer.cpp
    ../libuavcan/libuavcan/src/protocol/: uc_dynamic_node_id_client.cpp uc_node_status_provider.cpp
    ../libuavcan/libuavcan/src/transport/: uc_can_acceptance_filter_configurator.cpp uc_can_io.cpp uc_crc.cpp uc_dispatcher.cpp uc_frame.cpp uc_outgoing_transfer_registry.cpp uc_transfer.cpp uc_transfer_buffer.cpp uc_transfer_listener.cpp uc_transfer_receiver.cpp uc_transfer_sender.cpp
    ../libuavcan/libuavcan/src/: uc_data_type.cpp uc_dynamic_memory.cpp uc_error.cpp
  group libuavcanSTM32
    ../libuavcan/libuavcan_drivers/stm32/driver/src/: uc_stm32_can.cpp uc_stm32_thread.cpp uc_stm32_clock.cpp
  group UserInclude
    ../Inc/: chip.h gpio.h main.h stm32f3xx_hal_conf.h stm32f3xx_it.h flash.h fsu_libuavcan.h fsu_libuavcanSTM32.h FsuParamManager.h calibration.h liquid_level.h read_register.h register_init.h write_register.h
  group Application/UserCPP
    ../Src/: main.cpp fsu_libuavcan.cpp fsu_libuavcanSTM32.cpp FsuParamManager.cpp
  group libuavcanSTM32Include
    ../libuavcan/libuavcan_drivers/stm32/driver/include/uavcan_stm32/: build_config.hpp bxcan.hpp can.hpp clock.hpp thread.hpp uavcan_stm32.hpp
  group Application/User
    ../Src/: stm32f3xx_hal_msp.c main.c gpio.c stm32f3xx_it.c i2c.c
software components: CMSIS:CORE 5.0.1, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
